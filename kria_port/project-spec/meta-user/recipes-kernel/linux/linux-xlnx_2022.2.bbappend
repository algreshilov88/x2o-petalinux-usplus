FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Set-timeout-on-SD-card-clock-enable.patch \
	    file://0001-Xilinx-I2C-bus-recovery.patch \
	    "

