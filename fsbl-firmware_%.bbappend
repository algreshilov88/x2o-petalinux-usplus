YAML_COMPILER_FLAGS:append = " -DUHS_MODE_ENABLE"
