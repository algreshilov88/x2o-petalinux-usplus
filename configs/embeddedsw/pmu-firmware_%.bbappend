YAML_COMPILER_FLAGS:append = " -DENABLE_EM -DENABLE_SCHEDULER"
