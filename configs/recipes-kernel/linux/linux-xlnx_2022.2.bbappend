FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Added-static-DMA-proxy-Xilinx-XVC-drivers-for-X2O-pl.patch \
            file://0001-Xilinx-XVC-driver-fixes-for-X2O.patch \
            file://0007-DMA-Proxy-driver-fixes-for-X2O.patch \
            file://0008-DMA-Proxy-driver-more-fixes-for-X2O.patch \
	    file://0009-DMA-Proxy-driver-more-fixes-for-X2O.patch \
	    "

