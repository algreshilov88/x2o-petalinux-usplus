FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Added-static-DMA-proxy-Xilinx-XVC-drivers-for-X2O-pl.patch"

